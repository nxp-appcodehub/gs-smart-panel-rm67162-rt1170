# IAR project tiger_freertos_cm7.ewp, settings and files
configuration sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; DEBUG; CPU_MIMXRT1176DVMAA_cm7; CUSTOM_VGLITE_MEMORY_CONFIG=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; VG_COMMAND_CALL=1; VG_TARGET_FAST_CLEAR=0; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS; MCUXPRESSO_SDK; CORE1_IMAGE_COPY_TO_RAM; MCMGR_HANDLE_EXCEPTIONS=1
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pa092
  ICCARM.CCIncludePath2: ..; ../../video; ../../video/display; ../../video/display/rm67162; ../../video/display/rm68191; ../../drivers; ../../video/display/mipi_dsi_cmd; ../../video/display/rm68200; ../../video/display/dc/lcdifv2; ../../video/display/dc/dsi_cmd; ../../vglite/inc; ../../vglite/font; ../../vglite/font/mcufont/decoder; ../../vglite/VGLite/rtos; ../../vglite/VGLiteKernel; ../../vglite/VGLiteKernel/rtos; ../../video/display/dc/elcdif; ../../video/display/hx8394; ../../video/display/fbdev; ../../device; ../../utilities; ../../utilities/debug_console; ../../components/uart; ../../components/serial_manager; ../../components/lists; ../../xip; ../../components/silicon_id; ../../CMSIS; ../../video/display/dc; ../../freertos/freertos-kernel/include; ../../freertos/freertos-kernel/portable/IAR/ARM_CM4F; ../../mcmgr; ../../board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..
  OBJCOPY.OOCOutputFile: tiger_freertos_cm7.srec
  ILINK.IlinkOutputFile: tiger_freertos_cm7.out
  ILINK.IlinkKeepSymbols: _mipi_dcs_cm4_image
  ILINK.IlinkConfigDefines: __use_shmem__=1
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_sdram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=0; XIP_BOOT_HEADER_XMCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm7; CUSTOM_VGLITE_MEMORY_CONFIG=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; VG_COMMAND_CALL=1; VG_TARGET_FAST_CLEAR=0; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: ..; ../../vglite_support; ../../video; ../../video/display; ../../video/display/rm68191; ../../drivers; ../../video/display/mipi_dsi_cmd; ../../video/display/rm68200; ../../video/display/dc/lcdifv2; ../../vglite/inc; ../../vglite/font; ../../vglite/font/mcufont/decoder; ../../vglite/VGLite/rtos; ../../vglite/VGLiteKernel; ../../vglite/VGLiteKernel/rtos; ../../video/display/dc/elcdif; ../../video/display/hx8394; ../../video/display/fbdev; ../../device; ../../utilities; ../../utilities/debug_console; ../../components/uart; ../../components/serial_manager; ../../components/lists; ../../xip; ../../drivers; ../../components/silicon_id; ../../xmcd; ../../CMSIS; ../../video/display/dc; ../../freertos/freertos-kernel/include; ../../freertos/freertos-kernel/portable/IAR/ARM_CM4F
  ICCARM.CCOptLevel: 2
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
configuration sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1176DVMAA_cm7; CUSTOM_VGLITE_MEMORY_CONFIG=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; VG_COMMAND_CALL=1; VG_TARGET_FAST_CLEAR=0; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: ..; ../../vglite_support; ../../video; ../../video/display; ../../video/display/rm68191; ../../drivers; ../../video/display/mipi_dsi_cmd; ../../video/display/rm68200; ../../video/display/dc/lcdifv2; ../../vglite/inc; ../../vglite/font; ../../vglite/font/mcufont/decoder; ../../vglite/VGLite/rtos; ../../vglite/VGLiteKernel; ../../vglite/VGLiteKernel/rtos; ../../video/display/dc/elcdif; ../../video/display/hx8394; ../../video/display/fbdev; ../../device; ../../utilities; ../../utilities/debug_console; ../../components/uart; ../../components/serial_manager; ../../components/lists; ../../xip; ../../components/silicon_id; ../../xmcd; ../../CMSIS; ../../video/display/dc; ../../freertos/freertos-kernel/include; ../../freertos/freertos-kernel/portable/IAR/ARM_CM4F
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_sdram.icf
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=0; XIP_BOOT_HEADER_XMCD_ENABLE=1; USE_SDRAM; DATA_SECTION_IS_CACHEABLE=1; NDEBUG; CPU_MIMXRT1176DVMAA_cm7; CUSTOM_VGLITE_MEMORY_CONFIG=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; VG_COMMAND_CALL=1; VG_TARGET_FAST_CLEAR=0; SERIAL_PORT_TYPE_UART=1; SDK_OS_FREE_RTOS; MCUXPRESSO_SDK
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 2
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMXRT1176xxxxx_cm7_flexspi_nor_sdram.icf
  group board
    ../../board/: board.c board.h clock_config.c clock_config.h dcd.c dcd.h display_support.c display_support.h mipi_dsi_aux.c mipi_dsi_aux.h pin_mux.c pin_mux.h vglite_support.c vglite_support.h xmcd.c xmcd.h
  group CMSIS
    ../../CMSIS/: cachel1_armv7.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/lists
    ../../components/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/serial_manager
    ../../components/serial_manager/: fsl_component_serial_manager.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_port_uart.c fsl_component_serial_port_uart.h
  group component/silicon_id
    ../../components/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
  group component/uart
    ../../components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    ../../device/: fsl_device_registers.h MIMXRT1176_cm7.h MIMXRT1176_cm7_features.h system_MIMXRT1176_cm7.c system_MIMXRT1176_cm7.h
  group drivers
    ../../drivers/: fsl_anatop_ai.c fsl_anatop_ai.h fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_dcdc.c fsl_dcdc.h fsl_elcdif.c fsl_elcdif.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lcdifv2.c fsl_lcdifv2.h fsl_lpuart.c fsl_lpuart.h fsl_memory.h fsl_mipi_dsi.c fsl_mipi_dsi.h fsl_mu.c fsl_mu.h fsl_pmu.c fsl_pmu.h fsl_soc_mipi_csi2rx.c fsl_soc_mipi_csi2rx.h fsl_soc_src.c fsl_soc_src.h
  group evkmimxrt1170
    ../: evkmimxrt1170_connect_cm4_cm7side.jlinkscript
  group freertos/freertos-kernel
    ../../freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h
  group freertos/freertos-kernel/portable
    ../../freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/IAR/ARM_CM4F
    ../../freertos/freertos-kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos-kernel/portable/MemMang
    ../../freertos/freertos-kernel/portable/MemMang/: heap_4.c ReadMe.url
  group mcmgr
    ../../mcmgr/: mcmgr.c mcmgr.h mcmgr_internal_core_api.h mcmgr_internal_core_api_imxrt1170.c mcmgr_mu_internal.c
  group source
    ../../board/: FreeRTOSConfig.h
    ../: tiger_freertos.c tiger_paths.h vglite_window.c vglite_window.h
  group startup
    ../../startup/iar/: startup_MIMXRT1176_cm7.s
  group utilities
    ../../utilities/: fsl_assert.c fsl_str.c fsl_str.h
    ../../utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
  group vglite
    ../../vglite/: ChangeLogKSDK.txt
  group vglite/inc
    ../../vglite/inc/: vg_lite.h vg_lite_hal.h vg_lite_text.h
  group vglite/VGLite
    ../../vglite/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c
  group vglite/VGLite/rtos
    ../../vglite/VGLite/rtos/: vg_lite_os.c vg_lite_os.h
  group vglite/VGLiteKernel
    ../../vglite/VGLiteKernel/: vg_lite_hw.h vg_lite_kernel.c vg_lite_kernel.h
  group vglite/VGLiteKernel/rtos
    ../../vglite/VGLiteKernel/rtos/: vg_lite_hal.c vg_lite_platform.h
  group video
    ../../video/display/dc/: fsl_dc_fb.h
    ../../video/display/dc/dsi_cmd/: fsl_dc_fb_dsi_cmd.c fsl_dc_fb_dsi_cmd.h
    ../../video/display/dc/elcdif/: fsl_dc_fb_elcdif.c fsl_dc_fb_elcdif.h
    ../../video/display/dc/lcdifv2/: fsl_dc_fb_lcdifv2.c fsl_dc_fb_lcdifv2.h
    ../../video/display/: fsl_display.h
    ../../video/display/fbdev/: fsl_fbdev.c fsl_fbdev.h
    ../../video/display/hx8394/: fsl_hx8394.c fsl_hx8394.h
    ../../video/display/mipi_dsi_cmd/: fsl_mipi_dsi_cmd.c fsl_mipi_dsi_cmd.h
    ../../video/display/rm67162/: fsl_rm67162.c fsl_rm67162.h
    ../../video/display/rm68191/: fsl_rm68191.c fsl_rm68191.h
    ../../video/display/rm68200/: fsl_rm68200.c fsl_rm68200.h
    ../../video/: fsl_video_common.c fsl_video_common.h
  group xip
    ../../xip/: evkbmimxrt1170_flexspi_nor_config.c evkbmimxrt1170_flexspi_nor_config.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
